<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\AI_Camera_stm8.ewp</path>
    </project>
    <batchBuild />
</workspace>
